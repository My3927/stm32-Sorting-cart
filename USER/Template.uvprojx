# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\control;..\HARDWARE\data;..\HARDWARE\encoder;..\HARDWARE\JQ8400;..\HARDWARE\motor;..\HARDWARE\relay;..\HARDWARE\timer;..\HARDWARE\OLED;..\HARDWARE\REMOTE;..\HARDWARE\turn;..\HARDWARE\robotic_arm;..\HARDWARE\BEEP;..\HARDWARE\TCRT5000;..\HARDWARE\Kinematics_solution;..\HARDWARE\hcsr04;..\HARDWARE\DHT11;..\HARDWARE\LED;..\HARDWARE\GY_30;..\HARDWARE\hcsr04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../SYSTEM/sys/: sys.c
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/data/: data.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/JQ8400/: JQ8400.c
    ../HARDWARE/relay/: relay.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/turn/: turn.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/robotic_arm/: robotic_arm.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TCRT5000/: TCRC5000.c
    ../HARDWARE/GY_30/: GY_30.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/hcsr04/: hcsr04.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/Kinematics_solution/: Kinematics_solution.c
